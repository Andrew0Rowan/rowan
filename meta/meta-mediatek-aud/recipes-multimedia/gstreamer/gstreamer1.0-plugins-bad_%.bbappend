PACKAGECONFIG += " faad \"