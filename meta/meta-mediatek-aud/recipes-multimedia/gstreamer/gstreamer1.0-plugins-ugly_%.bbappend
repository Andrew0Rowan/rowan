PACKAGECONFIG += " mad \"