FILESEXTRAPATHS_prepend := "${THISDIR}/alsa-lib:"


SRC_URI += "file://0001-alsa-conf-add-mas-plugin-dev.patch \
            file://ioplug-status.patch \
"