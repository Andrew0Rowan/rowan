EXTRA_OECONF := " \
    -no-ssl3 \
    -no-asm \
"
