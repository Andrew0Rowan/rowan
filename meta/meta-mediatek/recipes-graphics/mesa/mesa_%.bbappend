PACKAGECONFIG_remove_mt2701 = "egl gles"
PROVIDES_remove_mt2701 = "virtual/libgles1 virtual/libgles2 virtual/egl virtual/libgl virtual/mesa"
PACKAGECONFIG_remove_mt8173p1v2 = "egl gles"
PROVIDES_remove_mt8173p1v2 = "virtual/libgles1 virtual/libgles2 virtual/egl virtual/libgl virtual/mesa"
