mali_ver="r6p2"
require mali_utgard.inc