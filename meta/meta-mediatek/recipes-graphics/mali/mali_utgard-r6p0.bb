mali_ver="r6p0"
require mali_utgard.inc