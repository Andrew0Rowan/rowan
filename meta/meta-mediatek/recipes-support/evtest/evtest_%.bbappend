FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

SRC_URI += "file://001_add_report_event_rate.patch"
