require linux-mtk-ramdisk-extension.inc

KERNEL_SRC = "${TOPDIR}/../src/kernel/linux/v4.9"
LINUX_VERSION = "4.9.17"
