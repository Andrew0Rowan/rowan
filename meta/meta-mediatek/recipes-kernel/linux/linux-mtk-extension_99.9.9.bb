require linux-mtk-extension.inc

KERNEL_SRC = "${TOPDIR}/../src/kernel/linux/upstream"
LINUX_VERSION = "99.9.9"
