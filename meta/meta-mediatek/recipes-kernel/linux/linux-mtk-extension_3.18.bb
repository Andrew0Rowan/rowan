require linux-mtk-extension.inc

KERNEL_SRC = "${TOPDIR}/../src/kernel/linux/v3.18"
LINUX_VERSION = "3.18.22"
