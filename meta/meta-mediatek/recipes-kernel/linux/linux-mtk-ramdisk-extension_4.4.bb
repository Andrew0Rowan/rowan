require linux-mtk-ramdisk-extension.inc

KERNEL_SRC = "${TOPDIR}/../src/kernel/linux/v4.4"
LINUX_VERSION = "4.4.0"
