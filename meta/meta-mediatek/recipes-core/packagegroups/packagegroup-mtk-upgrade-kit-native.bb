SUMMARY = "Mediatek Upgrade Kit"
LICENSE = "MediaTekProprietary"

inherit packagegroup

DEPENDS += "\
           platform-tools-native \
           fbtool-native \
           flashtool-native \
           "
