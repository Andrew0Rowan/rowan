SUMMARY = "Mediatek Upgrade Kit"
LICENSE = "MediaTekProprietary"

inherit packagegroup

DEPENDS += "\
           android-tools-fastboot \
           fbtool \
           "
